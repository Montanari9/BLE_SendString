# IAR project SampleAppThT.ewp, settings and files
configuration SampleApp_SERVER (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152RB ST STM32L152RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L152xD; USE_STM32L1XX_NUCLEO; USE_HAL_DRIVER; SERVER_ROLE
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L1xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB04A1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SampleAppThT.bin
  ILINK.IlinkOutputFile: SampleAppThT.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SampleApp_CLIENT (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L053x8 ST STM32L053x8
  General.CoreVariant: 35
  ICCARM.CCDefines: STM32L053xx; USE_STM32L0XX_NUCLEO; USE_HAL_DRIVER; CLIENT_ROLE
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB04A1
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
configuration ThroughputTest_SERVER (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L053x8 ST STM32L053x8
  General.CoreVariant: 35
  ICCARM.CCDefines: STM32L053xx; USE_STM32L0XX_NUCLEO; USE_HAL_DRIVER; SERVER_ROLE; THROUGHPUT_TEST; OPTIMIZED_SPI
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 2
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
configuration ThroughputTest_CLIENT (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L053x8 ST STM32L053x8
  General.CoreVariant: 35
  ICCARM.CCDefines: STM32L053xx; USE_STM32L0XX_NUCLEO; USE_HAL_DRIVER; CLIENT_ROLE; THROUGHPUT_TEST
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 2
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  group Application/EWARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l152xd.s
  group Application/User
    ../../Src/: bluenrg_interface.c clock.c cube_hal_l1.c main.c sample_service.c stm32xx_it.c uart_support.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/STM32L152RD_NUCLEO
    ../../../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDB04A1
    ../../../../../../Drivers/BSP/X-NUCLEO-IDB04A1/: stm32_bluenrg_ble.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_uart.c
  group Middlewares/STM32_BlueNRG/HCI
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c
  group Middlewares/STM32_BlueNRG/HCI/controller
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_utils_small.c
  group Middlewares/STM32_BlueNRG/Interface
    ../../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf_template.c
  group Middlewares/STM32_BlueNRG/Utils
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: ble_list.c gp_timer.c osal.c
